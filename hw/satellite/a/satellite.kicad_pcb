# Repository sequoia-hope/studio-amp (continued)

## KiCad design hw/satellite/a/satellite.kicad_pcb (continued)

Schematic: fpga.kicad_sch, Studio Amp satellite: ECP5 FPGA and configuration

Parts:
C801, C802, C803, C810, C813, C816, C819, C822, C828, C831: 10u; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
C804, C805, C806, C807, C808, C809, C811, C812, C814, C815, C817, C818, C820, C821, C823, C824, C826, C827, C829, C830, C832: 100n; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C825: 22u; C_0805_2012Metric; MPN CL21A226MAQNNNE; LCSC C45783
FB801: BLM18PG121; L_0603_1608Metric; MPN BLM18PG121SN1D; LCSC C14709
R801, R810, R822, R823, R824, R826, R827, R828, R829, R830, R831, R832, R833, R834, R835: 4k7; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
R802, R803, R804, R805, R806, R807, R808, R809, R811, R812, R813, R814, R815, R818, R819, R825: 1k; R_0402_1005Metric; MPN 0402WGF1001TCE; LCSC C11702
R816, R817, R820, R821: 330R; R_0402_1005Metric; MPN 0402WGF3300TCE; LCSC C25104
TP801: CLK_AUX; TestPoint_Pad_D1.0mm
U801: LFE5U-25F-7BG256I; Lattice_caBGA-256_14x14mm_Layout16x16_P0.8mm; MPN LFE5U-25F-7BG256I; LCSC C1550762

Connections:
+2V5: FB801.1; also elsewhere on the board
/fpga/VCCAUX: C810.1, C811.1, C812.1, FB801.2, U801.G11 (VCCAUX), U801.L7 (VCCAUX)
ACF_PULSE: R801.1; also elsewhere on the board
AMP_ARM: U801.R1 (PL35B/VREF1_6); also elsewhere on the board
AMP_CLK_T: U801.T2 (PL38D); also elsewhere on the board
AMP_CLK_W: U801.P2 (PL32B); also elsewhere on the board
AMP_EN_T: U801.T4 (PL44B); also elsewhere on the board
AMP_EN_W: U801.R5 (PL44A); also elsewhere on the board
DAC_L0: U801.N16 (PR32A); also elsewhere on the board
DAC_L1: U801.P15 (PR32B); also elsewhere on the board
DAC_L2: U801.P16 (PR35A); also elsewhere on the board
DAC_L3: U801.R16 (PR35B/VREF1_3); also elsewhere on the board
DAC_R0: U801.R13 (PR41C); also elsewhere on the board
DAC_R1: U801.T14 (PR41D); also elsewhere on the board
DAC_R2: U801.R12 (PR44A); also elsewhere on the board
DAC_R3: U801.T13 (PR44B); also elsewhere on the board
DC_T_n: R818.1; also elsewhere on the board
DC_W_n: R819.1; also elsewhere on the board
DISP_AUX7: U801.F15 (PR11C); also elsewhere on the board
DISP_AUX8: U801.F16 (PR14A); also elsewhere on the board
DISP_BLK: U801.E16 (PR11D); also elsewhere on the board
DISP_BL_PWM: U801.G15 (PR14B); also elsewhere on the board
DISP_CS: U801.E15 (PR8B); also elsewhere on the board
DISP_DC: U801.D16 (PR8A); also elsewhere on the board
DISP_RES: U801.C15 (PR5B); also elsewhere on the board
DISP_SCL: U801.B16 (PR2A); also elsewhere on the board
DISP_SDA: U801.C16 (PR5A); also elsewhere on the board
FAULT_T_n: R820.1; also elsewhere on the board
FAULT_W_n: R821.1; also elsewhere on the board
FPGA_CCLK: R825.2, U801.N9 (CCLK/MCLK/SCK); also elsewhere on the board
FPGA_DONE: R834.2, U801.P9 (DONE); also elsewhere on the board
FPGA_INITN: R833.2, U801.T9 (INITN); also elsewhere on the board
FPGA_MISO: U801.T7 (PB11A/D1/MISO); also elsewhere on the board
FPGA_MOSI: U801.T8 (PB11B/D0/MOSI); also elsewhere on the board
FPGA_PROGRAMN: R828.2, U801.R9 (PROGRAMN); also elsewhere on the board
FPGA_SN: R826.2, U801.R8 (PB13A/SN/CSN); also elsewhere on the board
FPGA_TCK: R830.1, U801.T10 (TCK); also elsewhere on the board
FPGA_TDI: R831.2, U801.R11 (TDI); also elsewhere on the board
FPGA_TDO: R835.2, U801.M10 (TDO); also elsewhere on the board
FPGA_TMS: R832.2, U801.T11 (TMS); also elsewhere on the board
HP_DET: R814.1; also elsewhere on the board
HP_EN: U801.M14 (PR32D); also elsewhere on the board
HP_FAULT_N: R815.1; also elsewhere on the board
IS_CS_n: R822.2, U801.L3 (PL32C); also elsewhere on the board
IS_SCLK: U801.M3 (PL32D); also elsewhere on the board
IS_SDI: U801.R3 (PL41B); also elsewhere on the board
IS_SDO: U801.P3 (PL38B); also elsewhere on the board
LED_EN: U801.H15 (PR20B); also elsewhere on the board
LED_FAULT_N: R811.1; also elsewhere on the board
LINK_CLK: U801.M16 (PR26C/PCLKT3_0); also elsewhere on the board
LINK_D0: U801.M7 (PB9B/D2/IO2); also elsewhere on the board
LINK_D1: U801.N7 (PB9A/D3/IO3); also elsewhere on the board
LINK_D2: U801.P7 (PB6B/D4/MOSI2); also elsewhere on the board
LINK_D3: U801.R7 (PB6A/D5/MISO2); also elsewhere on the board
LINK_D4: U801.R6 (PB4B/D6/IO6); also elsewhere on the board
LINK_D5: U801.T6 (PB4A/D7/IO7); also elsewhere on the board
LINK_D6: U801.P8 (PB13B/CS1N); also elsewhere on the board
LINK_D7: U801.M8 (PB15B/DOUT/CSON); also elsewhere on the board
LINK_DIR: U801.R15 (PR38C); also elsewhere on the board
LINK_IRQ: U801.M9 (PB18A/WRITEN); also elsewhere on the board
LINK_STB: U801.T15 (PR38D); also elsewhere on the board
LO_EN: U801.N14 (PR35D); also elsewhere on the board
MADC_BCK: U801.P13 (PR41A); also elsewhere on the board
MADC_DOUT: R816.1; also elsewhere on the board
MADC_LRCK: U801.R14 (PR41B); also elsewhere on the board
unnamed: R803.2, U801.A2 (PT4A)
unnamed: R808.2, U801.B3 (PT4B)
unnamed: R804.2, U801.A3 (PT6A)
unnamed: R805.2, U801.A4 (PT6B)
unnamed: R807.2, U801.B4 (PT11B)
unnamed: R806.2, U801.B5 (PT15B)
unnamed: R802.2, U801.A5 (PT18A)
unnamed: R809.2, U801.A6 (PT18B)
unnamed: R801.2, U801.B6 (PT22B)
unnamed: R812.2, U801.C14 (PR2C)
unnamed: R813.2, U801.E14 (PR5C)
unnamed: R811.2, U801.K16 (PR23C/PCLKT2_0)
unnamed: R816.2, U801.L16 (PR26A/PCLKT3_1)
unnamed: R814.2, U801.K13 (PR29A/GR_PCLK3_0)
unnamed: R817.2, U801.N13 (PR38A)
unnamed: R815.2, U801.P11 (PR47C/LRC_GPLL0T_IN)
unnamed: R821.2, U801.L1 (PL26A/PCLKT6_1)
unnamed: R820.2, U801.M1 (PL26C/PCLKT6_0)
unnamed: R818.2, U801.G1 (PL20A/GR_PCLK7_1)
unnamed: R819.2, U801.J1 (PL23A/PCLKT7_1)
unnamed: TP801.1, U801.K1 (PL23C/PCLKT7_0)
unnamed: R829.2, U801.N10 (CFG_0)
unnamed: R827.2, U801.N8 (PB15A/HOLDN/DI)
PDM_CLK: U801.L14 (PR32C); also elsewhere on the board
PDM_DAT: R817.1; also elsewhere on the board
PD_BT_N: R802.1; also elsewhere on the board
PD_PG_N: R803.1; also elsewhere on the board
PD_TPH_N: R804.1; also elsewhere on the board
PD_TPL_N: R805.1; also elsewhere on the board
PF_CS_n: R823.2, U801.K4 (PL29A/GR_PCLK6_0); also elsewhere on the board
PF_SCLK: U801.L4 (PL29C/GR_PCLK6_1); also elsewhere on the board
PF_SDI: U801.K5 (PL29B); also elsewhere on the board
PF_SDO_TA: U801.N5 (PL44D); also elsewhere on the board
PF_SDO_TB: U801.N6 (PL47B); also elsewhere on the board
PF_SDO_WA: U801.L5 (PL29D); also elsewhere on the board
PF_SDO_WB: U801.M5 (PL44C); also elsewhere on the board
PG_3V3Q: R806.1; also elsewhere on the board
PG_3V3_N: R807.1; also elsewhere on the board
PG_5V_N: R808.1; also elsewhere on the board
PHY_MDC: U801.A13 (PT65A); also elsewhere on the board
PHY_MDIO: U801.A14 (PT65B); also elsewhere on the board
PHY_NINT: U801.B13 (PT60A); also elsewhere on the board
PHY_NRST: U801.B12 (PT56A); also elsewhere on the board
POE_LOSS_N: R809.1, R810.2; also elsewhere on the board
PTP_PPS: U801.G16 (PR20A/GR_PCLK2_1); also elsewhere on the board
PWM_T_A: U801.R2 (PL38C); also elsewhere on the board
PWM_T_B: U801.R4 (PL41C); also elsewhere on the board
PWM_W_A: U801.N1 (PL32A); also elsewhere on the board
PWM_W_B: U801.P1 (PL35A); also elsewhere on the board
QWIIC_FAULT_N: R812.1; also elsewhere on the board
QWIIC_PWR_EN: U801.J16 (PR23A/PCLKT2_1); also elsewhere on the board
RMII_CRSDV: U801.B11 (PT49A); also elsewhere on the board
RMII_REFCLK: U801.C8 (PT35A/PCLKT1_0); also elsewhere on the board
RMII_RXD0: U801.A11 (PT53A); also elsewhere on the board
RMII_RXD1: U801.A12 (PT53B); also elsewhere on the board
RMII_TXD0: U801.A10 (PT42B); also elsewhere on the board
RMII_TXD1: U801.B10 (PT44A); also elsewhere on the board
RMII_TXEN: U801.A9 (PT42A); also elsewhere on the board
VB_CS_n: R824.2, U801.P4 (PL41A); also elsewhere on the board
VB_SCLK: U801.N3 (PL35D); also elsewhere on the board
VB_SDO: U801.M4 (PL35C); also elsewhere on the board
VCXO_CLK: U801.P6 (PL47C/LLC_GPLL0T_IN); also elsewhere on the board
VCXO_TUNE: U801.N4 (PL38A); also elsewhere on the board
VUSB_DET: R813.1; also elsewhere on the board

Notes on the sheet:
CORE: VCC +1V1 (1.045-1.155 V), 3 x 10u + 100n per ball; VCCAUX +2V5 through a 120 R bead, 10u + 100n per ball (TN-02038 Tab 3.1). I/O: every VCCIO on +3V3 (max 3.465 V), 10u per bank (22u on bank 6, the PWM bank) + 100n per ball. Layout: 100n under the ball field between the dog-bone vias; bulk ju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
Status from always-powered parts (A, B, C): 1k in series (hot socket, DS-02012 3.6). POE_LOSS_N: block B open drain, 4k7 pull-up on the net (pre-config sweep, E-pinmap.md). ACF_PULSE: 4k7 series (B's 74LVC2G08).
RMII to the LAN8720A (ethernet sheet): REFCLK on PCLKT1_0 (C8). MODE straps (RXD0/1, CRS_DV), MDIO, nRST and nINT pulls sit at the PHY. LPF: PULLMODE=UP on A11, A12, B11.
Display, LED and Qwiic power (block G/C). Always-driven inputs: 1k series, pair partners K15, D14, F14 left open. B15 (S0_IN) unused.
Audio (block F) and PIO link control (RP2350). MADC_DOUT, PDM_DAT: 330R; HP_FAULT_N, HP_DET: 1k; partners L15, P14, P12, K12 left open. LINK_CLK on PCLKT3_0 (M16).
CLK_AUX (K1, PCLKT7_0): spare clock input on a test pad (external low-jitter clock option). DC_W_n / DC_T_n: 1k series, partners J2 / H2 open.
Power stage (block D). PWM_* from ODDRX2F at 589.824 Mb/s (PLL x12 from VCXO_CLK on P6, LLC_GPLL0T_IN; P5 open). FAULT_*: always driven, 330R, partners L2 / M2 open. T3 open: it pairs with PWM_T_B (R4). ADC chip selects: 4k7 pull-ups keep the ADCs deselected through configuration.
sysCONFIG slave SPI from the RP2350 (SPI1, 37.5 MHz): CFGMDN[2:0] = 001: CFG0 4k7 up, CFG1/CFG2 to GND. CCLK 1k pull-up to VCCIO8 (TN-02038 Tab 6.2); 33R series at the RP2350 (mcu sheet). PROGRAMN, INITN, DONE, SN, HOLDN: 4k7 up. JTAG: TDI, TMS, TDO 4k7 up, TCK 4k7 down (TN-02038 Tab 6.1); header o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

Schematic: ethernet.kicad_sch, Studio Amp satellite: Ethernet PHY and clocks

Parts:
C901, C902, C905, C907, C908, C910, C911, C912, C915: 100n; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C903, C913, C914: 1u; C_0402_1005Metric; MPN CL05A105KA5NQNC; LCSC C52923
C904: 470p; C_0402_1005Metric; MPN 0402B471K500NT; LCSC C1537
C906, C909, C916: 4u7; C_0603_1608Metric; MPN CL10A475KO8NNNC; LCSC C19666
FB901, FB902: BLM18PG221; L_0603_1608Metric; MPN BLM18PG221SN1D; LCSC C80165
R901, R902, R903: 4k7; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
R904, R906, R907: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R905: 1k5; R_0402_1005Metric; MPN 0402WGF1501TCE; LCSC C25867
R908, R909, R910, R911: 49R9 1%; R_0603_1608Metric; MPN 0603WAF499JT5E; LCSC C23185
R912, R913: 270R; R_0402_1005Metric; MPN 0402WGF2700TCE; LCSC C25099
R914: 12k1 1%; R_0402_1005Metric; MPN 0402WGF1212TCE; LCSC C25852
R915, R916, R921: 33R; R_0402_1005Metric; MPN 0402WGF330JTCE; LCSC C25105
R917, R918: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R919: 0R; R_0402_1005Metric; MPN 0402WGF0000TCE; LCSC C17168
R920: 0R; R_0402_1005Metric; MPN 0402WGF0000TCE; LCSC C17168; not fitted
TP901: RXER; TestPoint_Pad_D1.0mm
U901: LAN8720AI; QFN-24-1EP_4x4mm_P0.5mm_EP2.5x2.5mm; MPN LAN8720AI-CP-TR; LCSC C17146
Y901: 50MHz; Oscillator_SMD_3225-4Pin_YXC_SX3V; MPN OT2EL4C4JI-111OLP-50M; LCSC C5203552
Y902: 24.576MHz VCXO; Oscillator_SMD_3225-4Pin_YXC_SX3V; MPN SX3V24.576B20100F30TNN; LCSC C5179997

Connections:
ETH_LED_G_A: R912.2; also elsewhere on the board
ETH_LED_Y_K: R913.2; also elsewhere on the board
ETH_RXN: R911.2, U901.22 (RXN); also elsewhere on the board
ETH_RXP: R910.2, U901.23 (RXP); also elsewhere on the board
ETH_TXN: R909.2, U901.20 (TXN); also elsewhere on the board
ETH_TXP: R908.2, U901.21 (TXP); also elsewhere on the board
MCLK_Q: R921.2; also elsewhere on the board
unnamed: C913.1, R917.2, R918.1
unnamed: C914.1, R918.2, R919.1
unnamed: R912.1, U901.3 (LED1/REGOFF)
unnamed: R913.1, U901.2 (LED2/~INTSEL)
unnamed: R914.1, U901.24 (RBIAS)
unnamed: TP901.1, U901.10 (RXER/PHYAD0)
unnamed: R915.2, U901.5 (XTAL1/CLKIN)
unnamed: R915.1, R916.1, Y901.3 (OUT)
unnamed: R919.2, R920.2, Y902.1 (Vc)
PHY_MDC: U901.13 (MDC); also elsewhere on the board
PHY_MDIO: R905.2, U901.12 (MDIO); also elsewhere on the board
PHY_NINT: R906.2, U901.14 (~INT/REFCLKO); also elsewhere on the board
PHY_NRST: R907.1, U901.15 (~RST); also elsewhere on the board
RMII_CRSDV: R903.2, U901.11 (CRS_DV/MODE2); also elsewhere on the board
RMII_REFCLK: R916.2; also elsewhere on the board
RMII_RXD0: R901.2, U901.8 (RXD0/MODE0); also elsewhere on the board
RMII_RXD1: R902.2, U901.7 (RXD1/MODE1); also elsewhere on the board
RMII_TXD0: U901.17 (TXD0); also elsewhere on the board
RMII_TXD1: U901.18 (TXD1); also elsewhere on the board
RMII_TXEN: R904.1, U901.16 (TXEN); also elsewhere on the board
VCXO_CLK: R921.1, Y902.3 (OUT); also elsewhere on the board
VCXO_TUNE: R917.1; also elsewhere on the board

Notes on the sheet:
Straps (sampled at nRST release): MODE[2:0] = 111 (all capable, auto-neg): 4k7 pull-ups beat the ECP5's 150 uA pre-config pull-down (review MAJOR-2); gateware: PULLMODE=UP, nRST released >= 25 ms after the rails. PHYAD0 = 0 (RXER internal pull-down).
nRST 10k down: PHY held in reset until the FPGA design releases it. MDIO 1k5 up (tau 30 ns).
49R9 + 100n at the MDI pins, symmetric per pair; pairs 100 R differential, no vias, over solid GND. J101 (poe_in): TX -> 11/10, RX -> 4/5.
LED1 (link, active high) -> green 20/19; LED2 (100M, active low) <- yellow 18/17 from VDD2A. Straps: REGOFF = 0 (internal 1.2 V on), nINTSEL = 1 (REF_CLK in). RBIAS 12k1 1%.
CT bypass, place at J101 pins 12 and 6
ETH_AVDD: analog 3.3 V island (VDD1A, VDD2A, 4 x 49R9, magnetics centre taps, yellow LED anode) behind a BLM18PG221 (<= 130 mA, 13 mV). VDDCR: internal 1.2 V regulator output, 1u || 470p at pin 6 (Tab 2-7).
RMII REFERENCE CLOCK: 50 MHz +-50 ppm CMOS XO, OE tied high. Two point-to-point branches, 33R each at the XO: PHY XTAL1 and ECP5 C8 (PCLKT1_0), <= 25 mm, matched +-5 mm, over solid GND.
Tune: 1-bit delta-sigma from ECP5 N4, 2 x (100k, 1u): 1.59 Hz poles, > 16 bits below 2 Hz; firmware clamps Vc to 0.3-3.0 V. Fixed-XO fallback on the same land: fit the 0R to VDD, remove the series 0R.
VCXO_CLK -> ECP5 P6 (LLC_GPLL0T_IN), shortest branch, no R. MCLK_Q -> block F's SN74LVC2G34 (MCLK_Q). VCXO within 10 mm of P6, RC filter beside Vc, nothing switching under the 1u caps.
AUDIO / PWM MASTER CLOCK, 24.576 MHz VCXO

Schematic: audio_out.kicad_sch, Studio Amp satellite: 1-bit DAC, headphone and line out

Parts:
C1001, C1004, C1008, C1011: 15n C0G; C_0805_2012Metric; MPN GRM2195C1H153JA01D; LCSC C97907
C1002, C1005, C1009, C1012: 8.2n C0G; C_0805_2012Metric; MPN GRM2195C1H822JA01D; LCSC C97908
C1003, C1006, C1010, C1013: 330p C0G; C_0603_1608Metric; MPN CC0603JRNPO9BN331; LCSC C62784
C1007, C1014: 100n C0G; C_1206_3216Metric; MPN GRM31C5C1H104JA01L; LCSC C97946
C1015, C1017: 4.7n C0G; C_0603_1608Metric; MPN CC0603JRNPO9BN472; LCSC C576818
C1016, C1018: 1n C0G; C_0603_1608Metric; MPN CC0603JRNPO9BN102; LCSC C106246
C1019, C1021, C1022, C1023, C1024, C1025, C1027, C1029, C1031, C1033, C1035: 100n 50V X7R; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C1020, C1026, C1028, C1030, C1032, C1034, C1036, C1037: 10u 25V X7R; C_1206_3216Metric; MPN CC1206KKX7R8BB106; LCSC C70462
D1001, D1002, D1003, D1004, D1005, D1008, D1009, D1010, D1011, D1014: BAV99; SOT-23; MPN BAV99,215; LCSC C2500
D1006, D1007, D1012, D1013, D1015, D1017: 1N4148WS; D_SOD-323; MPN 1N4148WS; LCSC C2128
D1016, D1018: BAT54A; SOT-23; MPN BAT54A,215; LCSC C130910
D1019, D1020, D1021, D1022, D1023: PESD15VL1BA; D_SOD-323; MPN PESD15VL1BA,115; LCSC C85378
FB1001, FB1002: 600R@100MHz; L_0603_1608Metric; MPN BLM18AG601SN1D; LCSC C19330
J1001: NMJ6HCD2; Jack_6.35mm_Neutrik_NMJ6HCD2_Horizontal; MPN NMJ6HCD2; LCSC C368502
J1002, J1003: RCJ-014; RCA_CUI_RCJ-01_Horizontal; MPN RCJ-014; LCSC C4991844
K1001, K1002: HFD4/5-SR; Relay_DPDT_Hongfa_HFD4-S_SMD; MPN HFD4/5-SR; LCSC C64399
Q1001, Q1006, Q1007, Q1012: BC857B; SOT-23; MPN BC857B,215; LCSC C59205
Q1002, Q1005, Q1008, Q1011, Q1015, Q1016: BC847B; SOT-23; MPN BC847B,215; LCSC C57668
Q1003, Q1009: BCP56-16; SOT-223-3_TabPin2; MPN BCP56-16,115; LCSC C92221
Q1004, Q1010: BCP53-16; SOT-223-3_TabPin2; MPN BCP53-16,115; LCSC C85085
Q1013, Q1014: AO3400A; SOT-23; MPN AO3400A; LCSC C20917
R1001, R1004, R1007, R1010, R1023, R1026, R1029, R1032, R1076: 33; R_0603_1608Metric; MPN 0603WAF330JT5E; LCSC C23140
R1002, R1003, R1005, R1006, R1008, R1009, R1011, R1012, R1024, R1025, R1027, R1028, R1030, R1031, R1033, R1034: 2.2k 0.1%; R_0603_1608Metric; MPN RT0603BRD072K2L; LCSC C861295
R1013, R1017, R1035, R1039: 560 0.1%; R_0603_1608Metric; MPN RT0603BRD07560RL; LCSC C861472
R1014, R1018, R1036, R1040: 750 0.1%; R_0603_1608Metric; MPN RT0603BRD07750RL; LCSC C861551
R1015, R1020, R1037, R1042: 3.9k 0.1%; R_0603_1608Metric; MPN RT0603BRD073K9L; LCSC C728592
R1016, R1019, R1038, R1041: 20k 0.1%; R_0603_1608Metric; MPN RT0603BRD0720KL; LCSC C723637
R1021, R1043: 1M 0.1%; R_0603_1608Metric; MPN RT0603BRD071ML; LCSC C326730
R1022, R1044: 100 0.25W; R_1206_3216Metric; MPN 1206W4F1000T5E; LCSC C17901
R1045, R1052, R1053, R1060, R1067, R1068: 100; R_0603_1608Metric; MPN 0603WAF1000T5E; LCSC C22775
R1046, R1061: 1k 0.25W; R_1206_3216Metric; MPN 1206W4F1001T5E; LCSC C4410
R1047, R1056, R1062, R1071: 10; R_0603_1608Metric; MPN 0603WAF100JT5E; LCSC C22859
R1048, R1050, R1063, R1065: 180; R_0603_1608Metric; MPN 0603WAF1800T5E; LCSC C22828
R1049, R1051, R1064, R1066: 15k; R_0603_1608Metric; MPN 0603WAF1502T5E; LCSC C22809
R1054, R1055, R1069, R1070: 15 0.1%; R_0603_1608Metric; MPN RT0603BRD0715RL; LCSC C705727
R1057, R1072: 4.7; R_0805_2012Metric; MPN FRC0805J4R7 TS; LCSC C2907327
R1058, R1073: 3.3k 0.1%; R_0603_1608Metric; MPN RT0603BRD073K3L; LCSC C309653
R1059, R1074: 1k 0.1%; R_0603_1608Metric; MPN RT0603BRD071KL; LCSC C110776
R1075: 22; R_0603_1608Metric; MPN 0603WAF220JT5E; LCSC C23345
R1077, R1079, R1082, R1083: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
R1078, R1080, R1088, R1089: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
R1081, R1084, R1085, R1086, R1087: 47k; R_0603_1608Metric; MPN 0603WAF4702T5E; LCSC C25819
R1090: 4.7k; R_0603_1608Metric; MPN 0603WAF4701T5E; LCSC C23162
U1001, U1002: SA5532A; SOIC-8_3.9x4.9mm_P1.27mm; MPN SA5532ADR; LCSC C83716
U1003: OPA2277UA; SOIC-8_3.9x4.9mm_P1.27mm; MPN OPA2277UA/2K5; LCSC C24460
U1004: 74LVC2G34; SOT-23-6; MPN SN74LVC2G34DBVR; LCSC C347589
U1005, U1006, U1007, U1008: 74LVC74A; TSSOP-14_4.4x5mm_P0.65mm; MPN 74LVC74APW,118; LCSC C6100

Connections:
+3V3_Q: C1019.1, C1020.1, C1021.1, C1022.1, C1023.1, C1024.1, U1004.5 (VCC), U1005.1 (~R), U1005.4 (~S), U1005.10 (~S), U1005.13 (~R), U1005.14 (VCC), U1006.1 (~R), U1006.4 (~S), U1006.10 (~S), U1006.13 (~R), U1006.14 (VCC), U1007.1 (~R), U1007.4 (~S), U1007.10 (~S), U1007.13 (~R), U1007.14 (VCC), U1008.1 (~R), U1008.4 (~S), U1008.10 (~S), U1008.13 (~R), U1008.14 (VCC); also elsewhere on the board
+5V: D1015.1 (K), D1017.1 (K), K1001.1 (+), K1002.1 (+); also elsewhere on the board
+15V: C1025.1, C1026.1, C1029.1, C1030.1, C1033.1, C1034.1, D1001.2 (K2), D1002.2 (K2), D1004.1 (A1), D1008.2 (K2), D1010.1 (A1), D1014.2 (K2), Q1003.2 (C), Q1003.4 (C), Q1009.2 (C), Q1009.4 (C), R1048.1, R1063.1, U1001.8 (V+), U1002.8 (V+), U1003.8 (V+); also elsewhere on the board
-15V: C1027.1, C1028.1, C1031.1, C1032.1, C1035.1, C1036.1, D1001.1 (A1), D1002.1 (A1), D1005.2 (K2), D1008.1 (A1), D1011.2 (K2), D1014.1 (A1), Q1004.2 (C), Q1004.4 (C), Q1010.2 (C), Q1010.4 (C), R1050.2, R1065.2, U1001.4 (V-), U1002.4 (V-), U1003.4 (V-); also elsewhere on the board
/audio_out/FILT_R: C1013.2, D1002.3 (K1A2), R1042.2, R1043.1, R1044.2, R1060.1, R1087.1, U1001.7
/audio_out/HPA_L: D1008.3 (K1A2), K1001.3 (COM1), R1057.2, R1084.1
/audio_out/HPA_R: D1014.3 (K1A2), K1001.6 (COM2), R1072.2, R1085.1
/audio_out/INL+: C1003.1, R1014.2, U1001.3 (+)
/audio_out/INR+: C1010.1, R1036.2, U1001.5 (+)
/audio_out/LO_L: K1002.3 (COM1), R1022.1
/audio_out/LO_R: K1002.6 (COM2), R1044.1
/audio_out/MCLK_FF: R1075.2, U1005.3 (C), U1005.11 (C), U1006.3 (C), U1006.11 (C), U1007.3 (C), U1007.11 (C), U1008.3 (C), U1008.11 (C)
/audio_out/NB_L: Q1002.3 (C), Q1006.3 (C), R1047.2, R1053.1
/audio_out/NB_R: Q1008.3 (C), Q1012.3 (C), R1062.2, R1068.1
/audio_out/NT_L: D1003.1 (A1), Q1001.3 (C), Q1005.3 (C), R1052.1
/audio_out/NT_R: D1009.1 (A1), Q1007.3 (C), Q1011.3 (C), R1067.1
/audio_out/N_DC: C1037.1, R1084.2, R1085.2, R1086.2, R1087.2, R1088.1, R1089.1
/audio_out/OUT_INT_L: C1016.2, Q1005.2 (E), Q1006.2 (E), R1054.2, R1055.1, R1056.1, R1057.1, R1059.2
/audio_out/OUT_INT_R: C1018.2, Q1011.2 (E), Q1012.2 (E), R1069.2, R1070.1, R1071.1, R1072.1, R1074.2
/audio_out/PL+: C1001.1, R1002.1, R1005.1, R1008.1, R1011.1, R1013.1
/audio_out/PL-: C1004.1, R1003.2, R1006.2, R1009.2, R1012.2, R1017.1
/audio_out/PR+: C1008.1, R1024.1, R1027.1, R1030.1, R1033.1, R1035.1
/audio_out/PR-: C1011.1, R1025.2, R1028.2, R1031.2, R1034.2, R1039.1
/audio_out/SERVO_L: C1007.2, R1016.1, U1003.1
/audio_out/SERVO_R: C1014.2, R1038.1, U1003.7
/audio_out/XL+: C1002.1, R1013.2, R1014.1, R1015.1, R1016.2
/audio_out/XL-: C1005.1, R1017.2, R1018.1, R1019.1, R1020.1
/audio_out/XR+: C1009.1, R1035.2, R1036.1, R1037.1, R1038.2
/audio_out/XR-: C1012.1, R1039.2, R1040.1, R1041.1, R1042.1
DAC_L0: R1001.1; also elsewhere on the board
DAC_L1: R1004.1; also elsewhere on the board
DAC_L2: R1007.1; also elsewhere on the board
DAC_L3: R1010.1; also elsewhere on the board
DAC_R0: R1023.1; also elsewhere on the board
DAC_R1: R1026.1; also elsewhere on the board
DAC_R2: R1029.1; also elsewhere on the board
DAC_R3: R1032.1; also elsewhere on the board
FILT_L: C1006.2, D1001.3 (K1A2), R1020.2, R1021.1, R1022.2, R1045.1, R1086.1, U1001.1; also elsewhere on the board
HP_DET: D1021.1 (A1), J1001.SN, R1081.2; also elsewhere on the board
HP_EN: R1078.1; also elsewhere on the board
HP_FAULT_N: D1016.1, D1018.1, Q1015.3 (C), Q1016.3 (C), R1090.2; also elsewhere on the board
LO_EN: R1080.1; also elsewhere on the board
MCLK_ADC: R1076.2; also elsewhere on the board
MCLK_Q: U1004.1, U1004.3; also elsewhere on the board
unnamed: C1015.1, R1056.2
unnamed: C1017.1, R1071.2
unnamed: D1003.3 (K1A2), R1046.2
unnamed: D1003.2 (K2), R1047.1
unnamed: D1004.2 (K2), Q1001.1 (B), R1049.1
unnamed: D1005.1 (A1), Q1002.1 (B), R1051.1
unnamed: D1006.2 (A), Q1003.3 (E), Q1005.1 (B), R1054.1
unnamed: D1006.1 (K), Q1003.1 (B), R1052.2
unnamed: D1007.2 (A), Q1004.1 (B), R1053.2
unnamed: D1007.1 (K), Q1004.3 (E), Q1006.1 (B), R1055.2
unnamed: D1009.3 (K1A2), R1061.2
unnamed: D1009.2 (K2), R1062.1
unnamed: D1010.2 (K2), Q1007.1 (B), R1064.1
unnamed: D1011.1 (A1), Q1008.1 (B), R1066.1
unnamed: D1012.2 (A), Q1009.3 (E), Q1011.1 (B), R1069.1
unnamed: D1012.1 (K), Q1009.1 (B), R1067.2
unnamed: D1013.2 (A), Q1010.1 (B), R1068.2
unnamed: D1013.1 (K), Q1010.3 (E), Q1012.1 (B), R1070.2
unnamed: D1015.2 (A), K1001.8 (-), Q1013.3 (D)
unnamed: D1017.2 (A), K1002.8 (-), Q1014.3 (D)
unnamed: D1019.1 (A1), FB1001.2, J1001.T
unnamed: D1020.1 (A1), FB1002.2, J1001.R
unnamed: D1022.1 (A1), J1002.2 (T), K1002.4 (NO1), R1082.1
unnamed: D1023.1 (A1), J1003.2 (T), K1002.5 (NO2), R1083.1
unnamed: FB1001.1, K1001.4 (NO1)
unnamed: FB1002.1, K1001.5 (NO2)
unnamed: Q1001.2 (E), R1048.2
unnamed: Q1002.2 (E), R1050.1
unnamed: Q1007.2 (E), R1063.2
unnamed: Q1008.2 (E), R1065.1
unnamed: D1016.3, Q1013.1 (G), R1077.1, R1078.2
unnamed: D1018.3, Q1014.1 (G), R1079.1, R1080.2
unnamed: Q1015.1 (B), R1088.2
unnamed: Q1016.2 (E), R1089.2
unnamed: R1046.1, U1002.1
unnamed: R1061.1, U1002.7
unnamed: R1075.1, U1004.6
unnamed: R1076.1, U1004.4
unnamed: C1006.1, R1018.2, U1001.2 (-)
unnamed: C1013.1, R1040.2, U1001.6 (-)
unnamed: R1045.2, U1002.3 (+)
unnamed: C1016.1, R1058.1, R1059.1, U1002.2 (-)
unnamed: R1060.2, U1002.5 (+)
unnamed: C1018.1, R1073.1, R1074.1, U1002.6 (-)
unnamed: C1007.1, R1021.2, U1003.2 (-)
unnamed: C1014.1, R1043.2, U1003.6 (-)
unnamed: R1001.2, U1005.2 (D)
unnamed: R1002.2, U1005.5 (Q)
unnamed: R1003.1, U1005.6 (~Q)
unnamed: R1004.2, U1005.12 (D)
unnamed: R1005.2, U1005.9 (Q)
unnamed: R1006.1, U1005.8 (~Q)
unnamed: R1007.2, U1006.2 (D)
unnamed: R1008.2, U1006.5 (Q)
unnamed: R1009.1, U1006.6 (~Q)
unnamed: R1010.2, U1006.12 (D)
unnamed: R1011.2, U1006.9 (Q)
unnamed: R1012.1, U1006.8 (~Q)
unnamed: R1023.2, U1007.2 (D)
unnamed: R1024.2, U1007.5 (Q)
unnamed: R1025.1, U1007.6 (~Q)
unnamed: R1026.2, U1007.12 (D)
unnamed: R1027.2, U1007.9 (Q)
unnamed: R1028.1, U1007.8 (~Q)
unnamed: R1029.2, U1008.2 (D)
unnamed: R1030.2, U1008.5 (Q)
unnamed: R1031.1, U1008.6 (~Q)
unnamed: R1032.2, U1008.12 (D)
unnamed: R1033.2, U1008.9 (Q)
unnamed: R1034.1, U1008.8 (~Q)
POE_LOSS_N: D1016.2, D1018.2; also elsewhere on the board

Notes on the sheet:
L 1-BIT DAC: 4-TAP FIR, 74LVC74 ON +3V3_Q, CLOCKED BY MCLK_FF (F-dac-74lvc74.md)
R_T 2.2k x 4 per side = 550 Ω; FIR zeros at 1.536 and 3.072 MHz
L RECONSTRUCTION FILTER, 3rd-ORDER BUTTERWORTH 47 kHz, GAIN 3.51 (F-filter-passives.md)
DC servo, OPA2277: IN+ to GND directly (offset <= IB x 1M = 2.8 mV, F-servo-opa2277.md)
LINE DRIVER: clamp + 100 Ω build-out -> line relay
R 1-BIT DAC: 4-TAP FIR, 74LVC74 ON +3V3_Q, CLOCKED BY MCLK_FF (F-dac-74lvc74.md)
R RECONSTRUCTION FILTER, 3rd-ORDER BUTTERWORTH 47 kHz, GAIN 3.51 (F-filter-passives.md)
L HEADPHONE STAGE, GAIN 1.30, CLASS AB INSIDE THE LOOP (F-hp-output-stage.md)
Q_ST/Q_SB: (2 VF - VBE)/180 = 4 mA
BCP56/BCP53: ≥ 2 cm² copper per tab (hard rule)
I_lim = VBE/R_E ≈ 43 mA
R HEADPHONE STAGE, GAIN 1.30, CLASS AB INSIDE THE LOOP (F-hp-output-stage.md)
MCLK_Q BUFFER ON +3V3_Q (F-clk-buffer.md)
VCXO branch, 33 Ω at the source (block E)
74LVC74 POWER UNITS, 100 nF AT PIN 14
+3V3_Q SNS: Kelvin to this row
OP-AMP SUPPLIES: 100 nF + 10 µF PER RAIL AT EACH PACKAGE
Power units (C) of the multi-unit symbols (74LVC74, SA5532, OPA2277); their logic and op-amp units are in the bands. Each cap's Decouples field names its pin, so layout puts it at that package.
OUTPUT RELAYS, DRIVERS, ESD, JACKS
NMJ6HCD2: R-40 waiver, decisions.md
Relays open when unpowered (F-mute-relay.md); ESD at every jack pin (F-esd.md)
/DC_TRIP (= HP_FAULT_N) or POE_LOSS_N low pulls both gates to ≤ 0.37 V: relays open in hardware (F-mute-relay.md)
LINE OUT L (RCA)
LINE OUT R (RCA)
DC DETECTOR: OPENS BOTH RELAYS (F-mute-relay.md)
Trips at ±0.6 V on N_DC: 2.4 V DC on one output, ~30 ms incl. relay release. FILT_L is a global label: the same net feeds the audio_in loopback. FILT_R is local.

Schematic: audio_in.kicad_sch, Studio Amp satellite: Measurement mic and MEMS mic

Parts:
C1101: 47u 16V Al; CP_Elec_5x5.4; MPN RST47UF16V034; LCSC C4747957
C1102, C1104: 1u 63V PET film; C_Rect_L7.2mm_W5.0mm_P5.00mm; MPN MKS2C041001F00JSSD; LCSC C92673
C1103, C1105, C1117: 1n C0G; C_0603_1608Metric; MPN CC0603JRNPO9BN102; LCSC C106246
C1106, C1108, C1110, C1112, C1114, C1118: 100n 50V X7R; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C1107, C1109: 10u 25V X5R; C_0805_2012Metric; MPN CL21A106KAYNNNE; LCSC C15850
C1111: 10u 16V Al; CP_Elec_4x5.4; MPN RST10UF16V013; LCSC C4747968
C1113, C1115: 10u 25V X7R; C_1206_3216Metric; MPN CC1206KKX7R8BB106; LCSC C70462
C1116: 1u 63V PET film; C_Rect_L7.2mm_W5.0mm_P5.00mm; MPN MKS2C041001F00JSSD; LCSC C92673; not fitted
D1101, D1102: PESD15VL1BA; D_SOD-323; MPN PESD15VL1BA,115; LCSC C85378
D1103: BAV99; SOT-23; MPN BAV99,215; LCSC C2500
D1104, D1105: BAT54S; SOT-23; MPN BAT54S,215; LCSC C47546
J1101: SJ1-3523N; Jack_3.5mm_CUI_SJ1-3523N_Horizontal; MPN SJ1-3523N; LCSC C20182914
MK1101: T3902; TDK_T3902_LGA-5_3.5x2.65mm; MPN MMICT390200012; LCSC C3171752
R1101, R1102, R1103, R1108, R1111, R1112: 2.2k; R_0603_1608Metric; MPN 0603WAF2201T5E; LCSC C4190
R1104: 470; R_0603_1608Metric; MPN 0603WAF4700T5E; LCSC C23179
R1105: 470k; R_0603_1608Metric; MPN 0603WAF4703T5E; LCSC C23178
R1106, R1109, R1113: 1k; R_0603_1608Metric; MPN 0603WAF1001T5E; LCSC C21190
R1107: 3k; R_0603_1608Metric; MPN 0603WAF3001T5E; LCSC C4211
R1110: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804; not fitted
R1114: 33; R_0603_1608Metric; MPN 0603WAF330JT5E; LCSC C23140
R1115: 10; R_0603_1608Metric; MPN 0603WAF100JT5E; LCSC C22859
U1101: SA5532A; SOIC-8_3.9x4.9mm_P1.27mm; MPN SA5532ADR; LCSC C83716
U1102: PCM1808; TSSOP-14_4.4x5mm_P0.65mm; MPN PCM1808PWR; LCSC C55513

Connections:
+5V_A: C1106.1, C1107.1, D1104.2 (K2), D1105.2 (K2), R1103.1, U1102.3 (VCC); also elsewhere on the board
+15V: C1112.1, C1113.1, D1103.2 (K2), U1101.8 (V+); also elsewhere on the board
-15V: C1114.1, C1115.1, D1103.1 (A1), U1101.4 (V-); also elsewhere on the board
/audio_in/ADC_VINL: C1105.1, R1109.2, U1102.13 (VINL)
/audio_in/ADC_VINR: C1117.1, R1113.2, U1102.14 (VINR)
/audio_in/ADC_VREF: C1110.1, C1111.1, U1102.1 (VREF)
/audio_in/MIC_BIAS: C1101.1, R1101.2, R1102.2, R1103.2
/audio_in/MIC_PRE: C1103.2, C1104.1, R1107.2, U1101.1
/audio_in/MIC_PRE_IN: D1103.3 (K1A2), R1104.2, R1105.1, U1101.3 (+)
/audio_in/MIC_TIP: C1102.1, D1102.1 (A1), J1101.T, R1102.1
FILT_L: R1110.1; also elsewhere on the board
MADC_BCK: U1102.8 (BCK); also elsewhere on the board
MADC_DOUT: U1102.9 (DOUT); also elsewhere on the board
MADC_LRCK: U1102.7 (LRCK); also elsewhere on the board
MCLK_ADC: U1102.6 (SCKI); also elsewhere on the board
unnamed: C1102.2, R1104.1
unnamed: C1104.2, R1108.1
unnamed: C1116.2, R1112.1
unnamed: D1101.1 (A1), J1101.R, R1101.1
unnamed: D1104.3 (K1A2), R1108.2, R1109.1
unnamed: D1105.3 (K1A2), R1112.2, R1113.1
unnamed: MK1101.4 (CLK), R1114.2
unnamed: C1118.1, MK1101.5 (VDD), R1115.1
unnamed: C1103.1, R1106.1, R1107.1, U1101.2 (-)
unnamed: R1110.2, R1111.1, U1101.5 (+)
unnamed: C1116.1, U1101.6 (-), U1101.7
PDM_CLK: R1114.1; also elsewhere on the board
PDM_DAT: MK1101.1 (DATA); also elsewhere on the board

Notes on the sheet:
EXT MIC JACK, ESD AND PLUG-IN POWER (R-15)
3.5 mm TRS, CUI SJ1-3523N T = mic signal + bias R = bias only, S = GND
Plug-in power: 5.0 V open circuit through 4.4 kΩ, 2.8-3.7 V at a 0.3-0.5 mA electret (R-15 deviation, F-overview.md). R_F with 47 µF: 1.5 Hz filter on +5V_A.
MIC PREAMP, +12 dB (SA5532 A)
Gain 1 + 3k/1k = 4.0 (+12 dB): clips at 110 dB SPL with a -28 dBV/Pa capsule. Line level plugged in by mistake swings ±5.7 V, inside the input range.
MIC ADC: PCM1808, I2S SLAVE, SCKI = 512 fs
MD1 = MD0 = L: slave, SCKI auto-detect FMT = L: I2S 24-bit
ECP5 P13 / R14 / L16 (E-pinmap.md); 330 Ω series on DOUT at block E. MCLK_ADC: SN74LVC2G34 2Y via 33 Ω (audio_out).
SA5532 SUPPLY (U1101)
100 nF + 10 µF per rail within 3 mm of pins 8 and 4 (F-opamp-sa5532.md)
LOOPBACK: LINE-OUT L (FILT_L) -> PCM1808 VINR (OPTIONAL, R_LA AND C_LB DNP)
Not fitted: R_LA and C_LB. With them, VINR records line-out L for latency and level calibration (room correction).
ON-BOARD MEMS MIC (R-16)
SELECT = GND: data on the right channel (after CLK falls)
Bottom port: Ø0.8 mm PCB hole, vent to the back panel (phase 4). No pull on DATA. Clock 3.072 MHz.

Schematic: io.kicad_sch, Studio Amp satellite: User I/O, debug and test points

Parts:
C1201: 4n7 2kV; C_1206_3216Metric; MPN 1206B472K202NT; LCSC C41017; not fitted
C1202, C1203, C1204, C1209, C1210, C1212, C1213, C1214, C1215: 100n; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C1205, C1207, C1211, C1220: 1u 50V; C_0603_1608Metric; MPN CL10A105KB8NNNC; LCSC C15849
C1206: 10u 25V; C_0805_2012Metric; MPN CL21A106KAYNNNE; LCSC C15850
C1208: 22u 25V; C_1206_3216Metric; MPN CL31A226KAHNNNE; LCSC C12891
C1216, C1217, C1218, C1219: 10n; C_0603_1608Metric; MPN 0603B103K500NT; LCSC C57112
D1201: SMF5.0A; D_SOD-123F; MPN SMF5.0A; LCSC C193402
D1202, D1203, D1204, D1205, D1207, D1208, D1209, D1210, D1211, D1212, D1213, D1214, D1215, D1216: PESD5V0S1BL; D_SOD-882; MPN PESD5V0S1BL,315; LCSC C84374
D1206: SMF6.0A; D_SOD-123F; MPN SMF6.0A; LCSC C123790
FB1201: BLM31KN601; L_1206_3216Metric; MPN BLM31KN601SN1L; LCSC C668306
FB1202: BLM18PG221; L_0603_1608Metric; MPN BLM18PG221SN1D; LCSC C80165
J1201: USB-C 16P TYPE-C-31-M-12; USB_C_Receptacle_HRO_TYPE-C-31-M-12; MPN TYPE-C-31-M-12; LCSC C165948
J1202: Qwiic JST SH 4P; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal; MPN SM04B-SRSS-TB(LF)(SN); LCSC C160404
J1203, J1204: JST SH 3P; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal; MPN 1.0-3PWT; LCSC C2763613
J1205: JST PH 4P; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical; MPN B4B-PH-K-S(LF)(SN); LCSC C131334
J1206: 2x6 header 2.54; PinHeader_2x06_P2.54mm_Vertical; MPN PZ254V-12-12P; LCSC C492423
J1207: 1x6 header 2.54; PinHeader_1x06_P2.54mm_Vertical; MPN PZ254V-11-06P; LCSC C492405
J1208: 1x8 socket 2.54; PinSocket_1x08_P2.54mm_Vertical; MPN 2.54-1*8P; LCSC C27438
JP1201, JP1204, JP1205, JP1224: bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP1202, JP1203, JP1206, JP1207, JP1208, JP1209, JP1210, JP1211, JP1212, JP1213, JP1214, JP1215, JP1216, JP1217, JP1218, JP1219, JP1220, JP1221, JP1222, JP1223, JP1225: open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1201: AO3401A; SOT-23; MPN AO3401A; LCSC C15127
Q1202: 2N7002; SOT-23; MPN 2N7002; LCSC C8545
R1201: 0R; R_0603_1608Metric; MPN 0603WAF0000T5E; LCSC C21189
R1202: 1M; R_0603_1608Metric; MPN 0603WAF1004T5E; LCSC C22935; not fitted
R1203, R1204: 5.1k; R_0603_1608Metric; MPN 0603WAF5101T5E; LCSC C23186
R1205: 15k; R_0603_1608Metric; MPN 0603WAF1502T5E; LCSC C22809
R1206: 22k; R_0603_1608Metric; MPN 0603WAF2202T5E; LCSC C31850
R1207, R1208: 2.2k; R_0603_1608Metric; MPN 0603WAF2201T5E; LCSC C4190
R1209, R1210: 4.7k; R_0603_1608Metric; MPN 0603WAF4701T5E; LCSC C23162
R1211, R1214, R1221, R1231, R1233, R1235, R1237: 10k; R_0603_1608Metric; MPN 0603WAF1002T5E; LCSC C25804
R1212: 150k; R_0603_1608Metric; MPN 0603WAF1503T5E; LCSC C22807
R1213, R1219, R1250, R1252: 100k; R_0603_1608Metric; MPN 0603WAF1003T5E; LCSC C25803
R1215, R1216, R1238, R1239, R1240, R1241: 33R; R_0603_1608Metric; MPN 0603WAF330JT5E; LCSC C23140
R1217, R1218, R1225, R1251: 100R; R_0603_1608Metric; MPN 0603WAF1000T5E; LCSC C22775
R1220: 23.2k; R_0603_1608Metric; MPN 0603WAF2322T5E; LCSC C23346
R1222, R1223, R1224, R1242, R1243, R1244, R1245, R1246, R1247, R1248, R1249: 47R; R_0603_1608Metric; MPN 0603WAF470JT5E; LCSC C23182
R1226, R1227, R1228, R1229, R1230, R1232, R1234, R1236: 1k; R_0603_1608Metric; MPN 0603WAF1001T5E; LCSC C21190
TP1201: pad VUSB; TestPoint_Pad_D1.0mm
TP1202: pad SCLB; TestPoint_Pad_D1.0mm
TP1203: pad SDAB; TestPoint_Pad_D1.0mm
TP1204: pad QWIIC_3V3; TestPoint_Pad_D1.0mm
TP1205: TP +5V_LED; TestPoint_Keystone_5015_Micro_Mini; MPN 5015; LCSC C2906768
TP1206: pad LED_DATA 5V; TestPoint_Pad_D1.0mm
TP1207: pad LED_CLK 5V; TestPoint_Pad_D1.0mm
TP1208: pad DISP_VCC; TestPoint_Pad_D1.0mm
TP1209: pad DISP_BL_SW; TestPoint_Pad_D1.0mm
TP1210: pad LED_EN; TestPoint_Pad_D1.0mm
TP1211: pad LED_FAULT_N; TestPoint_Pad_D1.0mm
TP1212: pad QWIIC_PWR_EN; TestPoint_Pad_D1.0mm
TP1213: pad QWIIC_FAULT_N; TestPoint_Pad_D1.0mm
TP1214: pad VDRV_EN; TestPoint_Pad_D1.0mm
TP1215: pad VDRV_PG; TestPoint_Pad_D1.0mm
TP1216: pad PTP_PPS; TestPoint_Pad_D1.0mm
TP1217: pad RUN; TestPoint_Pad_D1.0mm
TP1218, TP1219: TP GND; TestPoint_Keystone_5015_Micro_Mini; MPN 5015; LCSC C2906768
U1201: USBLC6-2SC6; SOT-23-6; MPN USBLC6-2SC6; LCSC C7519
U1202: TCA9617B; VSSOP-8_3x3mm_P0.65mm; MPN TCA9617BDGKR; LCSC C527429
U1203: TPS2553; SOT-23-6; MPN TPS2553DBVR; LCSC C55266
U1204, U1208, U1209, U1210: SRV05-4; SOT-23-6; MPN SRV05-4.TCT; LCSC C13612
U1205: TPS2553; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm; MPN TPS2553DRVR; LCSC C138719
U1206, U1207: SN74LV1T125; SOT-23-5; MPN SN74LV1T125DBVR; LCSC C473338

Connections:
+5V_LED: C1208.1, C1209.1, C1210.1, FB1201.1, TP1205.1, U1205.1 (OUT), U1206.5 (VCC), U1207.5 (VCC)
/io/CC1: J1201.A5 (CC1), R1203.1
/io/CC2: J1201.B5 (CC2), R1204.1
/io/DISP_P1: J1208.1, JP1202.1 (A), JP1203.1 (A), JP1204.2 (B), R1242.1, U1209.1 (IO1)
/io/DISP_P2: J1208.2, JP1205.1 (A), JP1206.1 (A), JP1207.2 (B), R1243.1, U1209.3 (IO2)
/io/DISP_P3: J1208.3, JP1208.1 (A), JP1209.1 (A), JP1210.2 (B), R1244.1, U1209.4 (IO3)
/io/DISP_P4: J1208.4, JP1211.1 (A), JP1212.1 (A), JP1213.2 (B), R1245.1, U1209.6 (IO4)
/io/DISP_P5: J1208.5, JP1214.1 (A), JP1215.1 (A), JP1216.2 (B), R1246.1, U1210.1 (IO1)
/io/DISP_P6: J1208.6, JP1217.1 (A), JP1218.1 (A), JP1219.2 (B), R1247.1, U1210.3 (IO2)
/io/DISP_P7: J1208.7, JP1220.1 (A), JP1221.1 (A), JP1222.2 (B), R1248.1, U1210.4 (IO3)
/io/DISP_P8: J1208.8, JP1223.1 (A), JP1224.1 (A), JP1225.2 (B), R1249.1, U1210.6 (IO4)
/io/JT_TCK: J1207.3, R1241.1, U1208.6 (IO4)
/io/JT_TDI: J1207.5, R1239.1, U1208.3 (IO2)
/io/JT_TDO: J1207.4, R1240.1, U1208.4 (IO3)
/io/JT_TMS: J1207.6, R1238.1, U1208.1 (IO1)
/io/KNOB_REF: C1211.1, J1206.1 (KNOB_REF), R1225.1
/io/QWIIC_SCL: J1202.4, R1207.2, TP1202.1, U1202.7 (SCLB), U1204.4 (IO3)
/io/QWIIC_SDA: J1202.3, R1208.2, TP1203.1, U1202.6 (SDAB), U1204.6 (IO4)
/io/USB_SHIELD: C1201.1, J1201.S1 (SHIELD), R1201.1, R1202.1
DISP_AUX7: R1242.2; also elsewhere on the board
DISP_AUX8: R1243.2; also elsewhere on the board
DISP_BLK: R1249.2; also elsewhere on the board
DISP_BL_PWM: R1251.1; also elsewhere on the board
DISP_CS: R1248.2; also elsewhere on the board
DISP_DC: R1247.2; also elsewhere on the board
DISP_RES: R1246.2; also elsewhere on the board
DISP_SCL: R1244.2; also elsewhere on the board
DISP_SDA: R1245.2; also elsewhere on the board
ENC1_A: C1216.1, R1230.2, R1231.2; also elsewhere on the board
ENC1_B: C1217.1, R1232.2, R1233.2; also elsewhere on the board
ENC2_A: C1218.1, R1234.2, R1235.2; also elsewhere on the board
ENC2_B: C1219.1, R1236.2, R1237.2; also elsewhere on the board
FPGA_TCK: R1241.2; also elsewhere on the board
FPGA_TDI: R1239.2; also elsewhere on the board
FPGA_TDO: R1240.2; also elsewhere on the board
FPGA_TMS: R1238.2; also elsewhere on the board
I2C1_SCL: R1209.2, U1202.2 (SCLA); also elsewhere on the board
I2C1_SDA: R1210.2, U1202.3 (SDAA); also elsewhere on the board
KNOB1: C1212.1, R1226.2; also elsewhere on the board
KNOB2: C1213.1, R1227.2; also elsewhere on the board
KNOB3: C1214.1, R1228.2; also elsewhere on the board
KNOB4: C1215.1, R1229.2; also elsewhere on the board
LED_CLK: U1207.2; also elsewhere on the board
LED_DATA: U1206.2; also elsewhere on the board
LED_EN: R1219.1, TP1210.1, U1205.4 (EN); also elsewhere on the board
LED_FAULT_N: R1221.2, TP1211.1, U1205.3 (~FAULT); also elsewhere on the board
unnamed: D1202.2 (A2), J1203.3, R1215.1
unnamed: D1203.2 (A2), J1203.1, R1216.1
unnamed: D1204.2 (A2), J1204.3, R1217.1
unnamed: D1205.2 (A2), J1204.1, R1218.1
unnamed: D1206.1 (K), FB1201.2, J1205.1 (+5V)
unnamed: D1207.2 (A2), J1205.3 (D), R1222.2, TP1206.1
unnamed: D1208.2 (A2), J1205.4 (C), R1223.2, TP1207.1
unnamed: D1209.2 (A2), J1206.3 (KNOB1), R1226.1
unnamed: D1210.2 (A2), J1206.4 (KNOB2), R1227.1
unnamed: D1211.2 (A2), J1206.5 (KNOB3), R1228.1
unnamed: D1212.2 (A2), J1206.6 (KNOB4), R1229.1
unnamed: D1213.2 (A2), J1206.7 (ENC1_A), R1230.1
unnamed: D1214.2 (A2), J1206.8 (ENC1_B), R1232.1
unnamed: D1215.2 (A2), J1206.9 (ENC2_A), R1234.1
unnamed: D1216.2 (A2), J1206.10 (ENC2_B), R1236.1
unnamed: J1201.A6 (D+), J1201.B6 (D+), U1201.3 (I/O2)
unnamed: J1201.A7 (D-), J1201.B7 (D-), U1201.1 (I/O1)
unnamed: J1206.11 (+3V3), R1224.2
unnamed: Q1201.1 (G), Q1202.3 (D), R1250.2
unnamed: Q1202.1 (G), R1251.2, R1252.1
unnamed: R1222.1, U1206.4
unnamed: R1223.1, U1207.4
unnamed: R1212.1, U1203.5 (ILIM)
unnamed: R1220.1, U1205.2 (ILIM)
PTP_PPS: TP1216.1; also elsewhere on the board
QWIIC_3V3: C1206.1, J1202.2, JP1201.1 (A), R1213.1, TP1204.1, U1203.6 (OUT), U1204.5 (VP)
QWIIC_FAULT_N: R1214.2, TP1213.1, U1203.4 (~FAULT); also elsewhere on the board
QWIIC_PWR_EN: R1211.1, TP1212.1, U1202.5 (EN), U1203.3 (EN); also elsewhere on the board
RUN: TP1217.1; also elsewhere on the board
SWCLK: R1216.2; also elsewhere on the board
SWDIO: R1215.2; also elsewhere on the board
UART0_RX: R1218.2; also elsewhere on the board
UART0_TX: R1217.2; also elsewhere on the board
USB_DM: U1201.6 (I/O1); also elsewhere on the board
USB_DP: U1201.4 (I/O2); also elsewhere on the board
VDRV_EN: TP1214.1; also elsewhere on the board
VDRV_PG: TP1215.1; also elsewhere on the board
VUSB_DET: C1202.1, R1205.2, R1206.1; also elsewhere on the board

Notes on the sheet:
USB-C USB 2.0 FS to the RP2350, sink only (G-usb-c.md)
Shell: 0R to GND fitted. Isolated option: remove the 0R, fit 1M || 4n7 2 kV (G-usb-c.md)
27R series at the RP2350 (block E)
QWIIC TCA9617B repeater + TPS2553 switch, 155-207 mA (G-qwiic.md)
1 GND 2 +3V3 3 SDA 4 SCL (Qwiic)
A-side 4.7k: drop if block E fits I2C1 pull-ups
No series R on SDA/SCL: a far-end low plus I*R must stay below VILB 0.4 V
DEBUG PROBE JST SH 3-pin, Sequoia's convention (G-debug-jtag.md)
SWD: 1 SWCLK 2 GND 3 SWDIO
UART: 1 RX 2 GND 3 TX
ADDRESSABLE LED OUTPUT TPS2553 1.03-1.20 A, SN74LV1T125 (G-led-out.md)
RILIM 23.2k: 1.03-1.20 A; firmware caps it by PoE class
KNOB / ENCODER HEADER 2x6 0.1 in, optional (G-knob.md)
KNOB_REF: RP2350 ADC_AVDD (block E) through 100R, so knob readings are ratiometric. Pots 10-50k.
FPGA JTAG 1x6 0.1 in, optional (G-debug-jtag.md)
1 +3V3 2 GND 3 TCK 4 TDO 5 TDI 6 TMS 4.7k pulls are on block E's sheet (TN-02038)
DISPLAY HEADER 8-pin 0.1 in socket, every position remappable (G-display.md)
default
GND
VCC
SCL
SDA
RES
BLK
Each position: a jumper to DISP_VCC, DISP_BL_SW (switched backlight) or GND, else 47R to its FPGA pin. Defaults for GND, VCC, SCL, SDA, RES, DC, CS, BLK: JP to GND on 1, VCC on 2, BLK on 8 bridged. An FPGA line whose position is jumpered must be constrained Hi-Z (block E).
DISP_VCC AND BACKLIGHT SWITCH (G-display.md)
PWM <= 2 kHz with the 100k gate pull-up (10k for faster PWM). Q off at power-up.
TEST POINTS (R-80, G-testpoints.md) rail pads sit at their rails

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
Board: 2 copper layers, 1261 parts (0 on the bottom side), 684 nets, no tracks yet.
